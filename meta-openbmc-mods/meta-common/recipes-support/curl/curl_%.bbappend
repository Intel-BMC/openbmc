PACKAGECONFIG_remove = "gnutls"
PACKAGECONFIG += " ssl"
