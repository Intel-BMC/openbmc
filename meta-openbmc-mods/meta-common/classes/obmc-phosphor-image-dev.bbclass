IMAGE_INSTALL:append = " \
        mtd-util \
        io-app \
        intel-fw-update \
        lpc-cmds \
        beeper-test \
        "
