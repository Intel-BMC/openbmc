${PN}-software-extras_remove = " \
        obmc-flash-bmc \
        obmc-mgr-download \
"
