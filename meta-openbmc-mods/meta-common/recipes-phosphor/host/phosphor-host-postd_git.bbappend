DEPENDS += " gtest"
