FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-add-Associations-endpoints-change-delay-timer.patch"
