FILESEXTRAPATHS_append := ":${THISDIR}/${PN}"

SRCREV = "c4522d2ea747e139dc97238b58c9609ac9d11776"
SRC_URI += "file://0001-Verify-that-certificate-is-loadable-in-SSL-context.patch"

