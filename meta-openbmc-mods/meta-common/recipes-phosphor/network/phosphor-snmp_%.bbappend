FILESEXTRAPATHS:append := ":${THISDIR}/${PN}"

# SRC_URI = "git://github.com/openbmc/phosphor-snmp"
SRCREV = "7350c77aa635cff08c5f1ee32e10679de7c5afda"
