RDEPENDS:${PN}:remove = "phosphor-settings-manager"
RDEPENDS:${PN} += " settings"
