FILESEXTRAPATHS:append := ":${THISDIR}/${PN}"

# Temporary pin to resolve build breaks
SRCREV = "2c867fbe284ae532f1329b87a86ad3f8cd382867"
