COMPATIBLE_MACHINE = "intel-ast2500-sam"
FILESEXTRAPATHS:prepend := "${THISDIR}/linux-aspeed:"
SRC_URI += "file://intel-ast2500-sam.cfg"
