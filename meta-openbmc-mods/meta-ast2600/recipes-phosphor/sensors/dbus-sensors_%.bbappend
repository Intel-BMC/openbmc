FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-ADCSensor-Fix-for-P3V3-sensor.patch"
