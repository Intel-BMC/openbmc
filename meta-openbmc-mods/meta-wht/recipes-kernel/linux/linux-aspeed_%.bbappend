FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += " \
    file://0001-Enable-GPIOE0-and-GPIOE2-pass-through-by-default.patch \
    "
