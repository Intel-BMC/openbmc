SUMMARY = "Wolfpass board wiring"
DESCRIPTION = "Board wiring information for the Wolfpass system."
PR = "r1"

inherit config-in-skeleton

LIC_FILES_CHKSUM = "file://${INTELBASE}/COPYING.apache-2.0;md5=34400b68072d710fecd0a2940a0d1658"

SRCREV = "946064239016e38cd1cc346047b1d26960c06cdb"
SKELETON_URI = "git://git@github.com/Intel-BMC/skeleton.git;protocol=ssh;branch=intel"
